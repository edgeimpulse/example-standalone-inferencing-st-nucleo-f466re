# Keil uVision project standalone_nucleo.uvprojx, settings and files
target Nucleo F466RE (6190000::V6.19::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: standalone_nucleo +hex
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EI_PORTING_STM32_NUCLEO=1,EI_PORTING_STM32_CUBEAI=0
  c misc: -Wno-c++98-compat -Wno-c++98-compat-pedantic
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Edge Impulse
    ./: ei_main.cpp ei_main.h ei_classifier_porting.cpp
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F446RETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F446RETx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group peripheral
    ./: uart.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0, CMSIS:NN Lib 4.0.0, EdgeImpulse:SDK 1.0.0, EdgeImpulse:model:Motion_recognition 1.0.44, Board Support:LED 1.1.0, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:TIM 1.8.1, Device:STM32Cube HAL:UART 1.8.1, Device:Startup 2.6.3
